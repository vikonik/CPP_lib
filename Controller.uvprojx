# Keil uVision project Controller.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: Controller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Relay;.\spi;.\Port;.\TFT_module;.\Timers;.\TouchScreen;.\ILI9488;.\Interrupt;.\Test;.\Delay;.\spi;.\MAX31865;.\RCC;.\W25Qxx;.\ADC;.\DS18B20;.\OWI;.\UART
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Main
    ./main/: main.cpp
  group Relay
    ./Relay/: relay.h relay.cpp
  group SPI
    ./spi/: spi.cpp spi.h
  group LED_IND
    ./LedInd/: ledInd.cpp
    ./ledInd/: ledInd.h
  group SensorButton
    ./sensorButton/: sensorButton.cpp sensorButton.h
  group Port
    ./Port/: port.cpp port.h
  group TFT_module
    ./TFT_module/: TFT_module.cpp TFT_module.h
  group TouchScreen
    ./TouchScreen/: touchScreen.cpp touchScreen.h
  group ILI9488
    ./ILI9488/: ILI9488.cpp ILI9488.h DefaultFonts.c
  group Timers
    ./Timers/: timers.cpp timers.h
  group Interrupt
    ./Interrupt/: MDR32F9Qx_it.h MDR32F9Qx_it.cpp
  group Delay
    ./Delay/: delay.cpp delay.h
  group MAX31865
    ./MAX31865/: MAX31865.cpp MAX31865.h
  group ADC
    ./ADC/: ADC.cpp ADC.h
  group UART
    ./UART/: uart.cpp uart.h
  group HEF4051
    ./HEF4051/: hef4051.cpp hef4051.h
  group RCC
    ./RCC/: RCC.cpp RCC.h
  group W25Qxx
    ./W25Qxx/: W25Qxx.cpp W25Qxx.h
  group DS18B20
    ./DS18B20/: DS18B20.cpp DS18B20.h
  group OWI
    ./OWI/: OWIBitFunctions.h OWIdefs.h OWIPolled.h OWISWBitFunctions.cpp OWI.h OWI.cpp
software components: Device:Startup 2.0.3, Drivers:ADC 2.0.3, Drivers:DMA 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:SSP 2.0.3, Drivers:TIMER 2.0.3, Drivers:UART 2.0.3, Drivers:WWDG 2.0.3
